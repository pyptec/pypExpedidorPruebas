# Keil uVision project verificador_v_01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: expedidor_v_01_raspberry +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Objects
  group Expedidor
    ./: main.c delay.c
    ./Objects/: Accescan.obj Clock.obj eeprom.obj io_sensores.obj lintech.obj Monitor.obj pantallas.obj prog.obj pto_paralelo.obj tibbo.obj uart.obj verificador.obj
  group Documentacion
    ./: Documentacion.txt
